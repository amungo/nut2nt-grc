<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>53000000</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>nut2nt</key>
<param><key>id</key><value>nut2nt_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>clk_source</key><value>0</value></param>
<param><key>clk_divider</key><value>15</value></param>
<param><key>ch_enabled_0</key><value>True</value></param>
<param><key>ch_gnss_0</key><value>0</value></param>
<param><key>ch_if_band_0</key><value>22</value></param>
<param><key>ch_enabled_1</key><value>True</value></param>
<param><key>ch_gnss_1</key><value>0</value></param>
<param><key>ch_if_band_1</key><value>22</value></param>
<param><key>ch_enabled_2</key><value>True</value></param>
<param><key>ch_gnss_2</key><value>0</value></param>
<param><key>ch_if_band_2</key><value>22</value></param>
<param><key>ch_enabled_3</key><value>True</value></param>
<param><key>ch_gnss_3</key><value>0</value></param>
<param><key>ch_if_band_3</key><value>22</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>config_file</key><value>ConfigSet01.hex</value></param>
<param><key>firmware_file</key><value>fx3.img</value></param>
<param><key>pll_freq_a</key><value>1590000000</value></param>
<param><key>pll_freq_b</key><value>1590000000</value></param>
<param><key>lo_source</key><value>0</value></param>
<param><key>ecp5_alg</key><value>algo.sea</value></param>
<param><key>ecp5_data</key><value>data.sed</value></param>
<param><key>output_type</key><value>short</value></param>
<param><key>rx_block_size</key><value>204800</value></param>
<param><key>rx_block_num</key><value>16</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nut2nt_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
